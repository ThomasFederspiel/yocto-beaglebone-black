FILESEXTRAPATHS_prepend := "${THISDIR}/lttng_modules:"

SRC_URI += "file://rt-patch-version.sh.patch;apply=yes"

