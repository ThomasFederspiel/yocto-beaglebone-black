# Installed via rtl8188eu package instead
PACKAGES =+ " ${PN}-rtl8188eu"
LICENSE_${PN}-rtl8188eu = "Firmware-rtlwifi"
FILES_${PN}-rtl8188eu = " /lib/firmware/rtlwifi/rtl8188eufw.bin"



